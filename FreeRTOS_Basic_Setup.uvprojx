# Keil uVision project FreeRTOS_Basic_Setup.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_Basic_Setup
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FreeRTOSv10.2.1\FreeRTOS\Source\include;.\FreeRTOSv10.2.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS
    ./FreeRTOSv10.2.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOSv10.2.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOSv10.2.1/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c FreeRTOSConfig.h
  group UserApplication
    ./: main.c led.h led.c delay.h delay.c sys.h sys.c misc.h misc.c
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:Startup 2.6.3
